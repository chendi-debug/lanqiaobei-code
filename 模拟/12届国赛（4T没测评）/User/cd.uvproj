# Keil uVision project cd.uvproj, settings and files
target 25031350226 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: cd +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: Key.c Led.c Seg.c Init.c iic.c ultrasound.c
    ../../../模板/西风大模板/Driver/: ds1302.c
