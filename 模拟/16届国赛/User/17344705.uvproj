# Keil uVision project 17344705.uvproj, settings and files
target 17344705 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 17344705 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: Init.c Led.c Seg.c Key.c Distance.c onewire.c ds1302.c Uart.c
