# Keil uVision project 25031350226.uvproj, settings and files
target 25031350226 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 25031350226 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group Driver
    ./: STARTUP.A51
    ../Driver/: Key.c Init.c Led.c Seg.c
  group User
    ./: main.c
