# Keil uVision project Project.uvproj, settings and files
target 25031350226 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: ds1302.c key.c led.c onewire.c seg.c init.c
    ../../../V4T与调度器/第8届省赛/Driver/: iic.c
